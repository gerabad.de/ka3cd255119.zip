Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_5/temp/tmp_2208_93_nDBu4/format_1/1438(architecture=300).ifc
Time: 2025-08-08T11:36:29
Made in: PARTsolutions

# IfcProject, 1438(architecture=300)
Description: PURO NEXT DUO

# IfcDiscreteAccessory, 1438(architecture=300)
In: BUILDING
Description: 1438(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1438
ePset_PARTsolutions - NB: 1438(architecture=300); NN: 1438; NT: PURO NEXT DUO; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 1438(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 1438; B: 1438.png; C: PURO NEXT DUO; E: KALDEWEI; EF000049: 1700; EF004567: 750
